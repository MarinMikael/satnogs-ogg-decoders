options:
  parameters:
    generate_options: no_gui
    id: ogg_bpsk_decoder
    output_language: python
    run_options: run
    title: Satnogs OGG BPSK to AX25
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: bpsk_constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: decimation
  id: variable
  parameters:
    value: satnogs.find_decimation(baudrate, 2, audio_samp_rate,sps)
  states: {}
- name: if_freq
  id: variable
  parameters:
    value: '12000'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (baudrate*decimation)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: variable_ax25_decoder_0
  id: variable_ax25_decoder
  parameters:
    addr: '''ASCL'''
    crc_check: 'True'
    descrambling: 'True'
    error_correction: 'False'
    frame_len: '1024'
    promisc: 'True'
    ssid: '0'
  states: {}
- name: analog_agc2_xx_0_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-3'
    gain: '1.0'
    max_gain: '65536'
    reference: '0.5'
    type: complex
  states: {state: bypassed}
- name: analog_agc2_xx_0_0_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-3'
    decay_rate: '1e-3'
    gain: '1.0'
    max_gain: '65536'
    reference: '0.5'
    type: complex
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: baudrate
  id: parameter
  parameters:
    type: eng_float
    value: '1200'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    comment: |-
      Add a frequency offset equal the baudrate
      to move the audio representation of the
      signal to the audable frequencies
    phase_inc: '-2.0 * math.pi * (if_freq / audio_samp_rate)'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: samp_rate*170
    type: complex
  states: {state: bypassed}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*1
    type: complex
  states: {state: bypassed}
- name: decoded_file
  id: parameter
  parameters:
    type: str
    value: '"/home/mikael/satnogs_kafasat/decoded/"'
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    constellation: bpsk_constellation
    fmax: '0.25'
    fmin: '-0.25'
    loop_bw: 2.0 * math.pi/100.0
    showports: 'True'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.1'
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 2.0 * math.pi/100.0
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: excess_bw
  id: parameter
  parameters:
    comment: |-
      The BPSK excess bandwidth setup.
      Used in filtering.
    type: eng_float
    value: '0.5'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: baudrate/2 + excess_bw *baudrate/2 + abs(max_cfo)
    decim: decimation // sps
    gain: '1'
    samp_rate: baudrate*decimation
    type: fir_filter_ccf
    width: baudrate / 10.0
    win: firdes.WIN_HAMMING
  states: {}
- name: max_cfo
  id: parameter
  parameters:
    comment: |-
      The maximum offset allowed from the carrier.
      Used for filtering. Larger values allow decoding
      of frames with large frequency drifts,
       but degrades  reception performance.
    type: eng_float
    value: '2000.0'
  states: {}
- name: ogg_file
  id: parameter
  parameters:
    type: str
    value: /home/mikael/satnogs/records/satnogs_6159130_2022-07-02T07-43-45.ogg
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '80'
    nfilts: '32'
    rrate: (baudrate*decimation)/audio_samp_rate
    type: ccf
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: '512'
    type: complex
    update_time: '0.05'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    int_max: '-30'
    int_min: '-50'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: satnogs_frame_decoder_0_0
  id: satnogs_frame_decoder
  parameters:
    decoder_object: variable_ax25_decoder_0
    itype: byte
    vlen: '1'
  states: {}
- name: satnogs_frame_file_sink_0_1_0
  id: satnogs_frame_file_sink
  parameters:
    output_type: '0'
    prefix_name: decoded_file
  states: {}
- name: satnogs_frame_file_sink_0_1_0_0
  id: satnogs_frame_file_sink
  parameters:
    output_type: '1'
    prefix_name: input_file + ".hex"
  states: {state: disabled}
- name: satnogs_frame_file_sink_0_1_0_0_0
  id: satnogs_frame_file_sink
  parameters:
    output_type: '0'
    prefix_name: decoded_file
  states: {state: disabled}
- name: satnogs_json_converter_0
  id: satnogs_json_converter
  parameters:
    extra: ''
  states: {}
- name: satnogs_ogg_source_0
  id: satnogs_ogg_source
  parameters:
    channels: '1'
    filename: ogg_file
    repeat: 'False'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: iq_stream
  states: {}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: synced_stream
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: synced_stream
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: iq_stream
  states: {}

connections:
- [analog_agc2_xx_0_0, '0', low_pass_filter_0_0, '0']
- [analog_agc2_xx_0_0_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', blocks_rotator_cc_0_0, '0']
- [blocks_rotator_cc_0_0, '0', pfb_arb_resampler_xxx_0, '0']
- [blocks_skiphead_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', virtual_sink_1, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_null_sink_0, '0']
- [digital_constellation_receiver_cb_0, '0', satnogs_frame_decoder_0_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_waterfall_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_1_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', digital_costas_loop_cc_0, '0']
- [low_pass_filter_0_0, '0', analog_agc2_xx_0_0_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_skiphead_0, '0']
- [satnogs_frame_decoder_0_0, out, satnogs_frame_file_sink_0_1_0_0, frame]
- [satnogs_frame_decoder_0_0, out, satnogs_frame_file_sink_0_1_0_0_0, frame]
- [satnogs_frame_decoder_0_0, out, satnogs_json_converter_0, in]
- [satnogs_json_converter_0, out, satnogs_frame_file_sink_0_1_0, frame]
- [satnogs_ogg_source_0, '0', blocks_float_to_complex_0, '0']
- [virtual_source_0, '0', digital_constellation_receiver_cb_0, '0']
- [virtual_source_1, '0', analog_agc2_xx_0_0, '0']

metadata:
  file_format: 1
