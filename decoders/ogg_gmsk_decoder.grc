options:
  parameters:
    author: Manolis Surligas (surligas@gmail.com)
    description: Generic FSK/MSK decoder supporting AX.25 and AX.100 framing schemes
    generate_options: no_gui
    id: ogg_gmsk_decoder
    output_language: python
    run_options: run
    title: ogg_gmsk_decoder
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: available_framings
  id: variable
  parameters:
    comment: |-
      Dictionary holding all the available framing schemes.
      Currently supported:
      * AX.25 (key: ax25)
      * AX.100 Mode 5 (key: ax100_mode5)
      * AX.100 Mode 6 (key: ax100_mode6)
    value: '{''ax25'':variable_ax25_decoder_0, ''ax100_mode5'':variable_ax100_mode5_decoder_0,  ''ax100_mode6'':variable_ax100_mode6_decoder_0}'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: max(4,satnogs.find_decimation(baudrate, 2, audio_samp_rate))
  states: {state: disabled}
- name: variable_ax100_mode5_decoder_0
  id: variable_ax100_mode5_decoder
  parameters:
    crc: satnogs.crc.CRC32_C
    preamble: '[]'
    preamble_thrsh: '0'
    rs: 'True'
    sync_thrsh: '3'
    sync_word: '[0x93, 0x0B, 0x51, 0xDE]'
    whitening: ' satnogs.whitening.make_ccsds(True)'
  states: {}
- name: variable_ax100_mode6_decoder_0
  id: variable_ax100_mode6_decoder
  parameters:
    crc: satnogs.crc.CRC32_C
    descramble: 'True'
    whitening: satnogs.whitening_make_ccsds(True)
  states: {}
- name: variable_ax25_decoder_0
  id: variable_ax25_decoder
  parameters:
    addr: '''GND'''
    crc_check: 'True'
    descrambling: 'True'
    error_correction: 'False'
    frame_len: '1024'
    promisc: 'True'
    ssid: '0'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1.2'
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '0.9'
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0_0_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1.0'
  states: {state: disabled}
- name: antenna
  id: parameter
  parameters:
    type: str
    value: '""'
  states: {state: disabled}
- name: baudrate
  id: parameter
  parameters:
    type: eng_float
    value: '1200'
  states: {}
- name: bb_freq
  id: parameter
  parameters:
    label: Baseband CORDIC frequency (if the device supports it)
    type: eng_float
    value: '0.0'
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: 1024//2
    type: complex
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1024'
    max_iter: '4096'
    scale: 1.0/1024.0
    type: float
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_udp_sink_0_0
  id: blocks_udp_sink
  parameters:
    comment: |-
      Complex doppler corrected IQ over UDP.
      Sample rate will need to be calculated and specified.
      Example; use with: gr-satellites --udp --iq --udp_raw
    eof: 'True'
    ipaddr: udp_dump_host
    port: udp_dump_port
    psize: '1472'
    type: complex
    vlen: '1'
  states: {state: disabled}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: '1.0'
    samp_rate: baudrate*decimation
    sensitivity: '-baudrate*decimation'
  states: {state: disabled}
- name: bw
  id: parameter
  parameters:
    comment: |-
      The bandwidth should configure RF filters on some devices.
      Set to 0.0 for automatic calculation.
    label: Bandwidth
    type: eng_float
    value: '0.0'
  states: {state: disabled}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: ff
  states: {state: disabled}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: ff
  states: {state: disabled}
- name: dc_removal
  id: parameter
  parameters:
    label: Remove automatically the DC offset (if the device support it)
    type: str
    value: '"False"'
  states: {state: disabled}
- name: decoded_data_file_path
  id: parameter
  parameters:
    type: str
    value: '"/home/mikael/satnogs_kafasat/decoded/"'
  states: {state: disabled}
- name: decoded_file
  id: parameter
  parameters:
    type: str
    value: '"/home/mikael/satnogs_kafasat/decoded/"'
  states: {}
- name: dev_args
  id: parameter
  parameters:
    label: Device arguments
    type: str
    value: '""'
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: 0.5/8.0
    gain_omega: 2 * math.pi / 100
    mu: '0.5'
    omega: '2'
    omega_relative_limit: '0.01'
    type: float
  states: {}
- name: doppler_correction_per_sec
  id: parameter
  parameters:
    type: intx
    value: '20'
  states: {state: disabled}
- name: enable_iq_dump
  id: parameter
  parameters:
    type: intx
    value: '0'
  states: {state: disabled}
- name: file_path
  id: parameter
  parameters:
    type: str
    value: '"test.wav"'
  states: {state: disabled}
- name: framing
  id: parameter
  parameters:
    label: the framing scheme to use [ax25, ax100_mode5, ax100_mode6]
    type: str
    value: '"ax25"'
  states: {}
- name: gain
  id: parameter
  parameters:
    comment: |-
      Generic gain value. 
      Each Soapy module
      will try to linearize this
      value by properly setting
      the device specific gains.
    type: eng_float
    value: '0.0'
  states: {state: disabled}
- name: gain_mode
  id: parameter
  parameters:
    comment: |-
      Set the gain mode of the Soapy.
      Can be "Overall", "Specific"
      or "Settings Field"
    type: str
    value: '"Overall"'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: iq_file_path
  id: parameter
  parameters:
    type: str
    value: '"/tmp/iq.dat"'
  states: {state: disabled}
- name: lo_offset
  id: parameter
  parameters:
    comment: |-
      To avoid the SDR carrier at the DC
      we shift the LO a little further
    type: eng_float
    value: 100e3
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 0.625 * baudrate
    decim: decimation // 2
    gain: '1'
    samp_rate: baudrate*decimation
    type: fir_filter_ccf
    width: baudrate / 8.0
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    comment: |-
      Perform a relaxed filter to increase 
      the performance of the auto frequency
      correction
    cutoff_freq: baudrate*1.25
    decim: '1'
    gain: '1'
    samp_rate: baudrate*decimation
    type: fir_filter_ccf
    width: baudrate / 2.0
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: ogg_file
  id: parameter
  parameters:
    type: str
    value: /home/mikael/satnogs_kafasat/satnogs_ogg/satnogs_8523554_2023-11-16T04-34-53.ogg
  states: {}
- name: other_settings
  id: parameter
  parameters:
    label: Soapy Channel other settings
    type: str
    value: '""'
  states: {state: disabled}
- name: pfb_arb_resampler_xxx_1
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '80'
    nfilts: '32'
    rrate: (audio_samp_rate) / (baudrate*2)
    type: fff
  states: {state: disabled}
- name: pfb_arb_resampler_xxx_1_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '80'
    nfilts: '32'
    rrate: (baudrate*2)/(audio_samp_rate)
    type: fff
  states: {}
- name: ppm
  id: parameter
  parameters:
    comment: |-
      The frequency correction in PPM
      to correct for a local oscillator frequency deviation
    type: eng_float
    value: '0'
  states: {state: disabled}
- name: rigctl_port
  id: parameter
  parameters:
    type: intx
    value: '4532'
  states: {state: disabled}
- name: rx_freq
  id: parameter
  parameters:
    type: eng_float
    value: '435835000'
  states: {state: disabled}
- name: samp_rate_rx
  id: parameter
  parameters:
    label: Device Sampling rate
    type: eng_float
    value: 2.048e6
  states: {state: disabled}
- name: satnogs_doppler_compensation_0
  id: satnogs_doppler_compensation
  parameters:
    compensate: '1'
    fine_correction: '0'
    lo_offset: lo_offset
    out_samp_rate: baudrate*decimation
    samp_rate: samp_rate_rx
    sat_freq: rx_freq
  states: {state: disabled}
- name: satnogs_frame_decoder_0_0
  id: satnogs_frame_decoder
  parameters:
    decoder_object: available_framings[framing]
    itype: byte
    vlen: '1'
  states: {}
- name: satnogs_frame_file_sink_0_1_0
  id: satnogs_frame_file_sink
  parameters:
    output_type: '0'
    prefix_name: decoded_file
  states: {}
- name: satnogs_iq_sink_0
  id: satnogs_iq_sink
  parameters:
    activate: enable_iq_dump
    append: 'False'
    filename: iq_file_path
    scale: '16768'
  states: {state: disabled}
- name: satnogs_json_converter_0
  id: satnogs_json_converter
  parameters:
    extra: ''
  states: {}
- name: satnogs_ogg_encoder_0
  id: satnogs_ogg_encoder
  parameters:
    filename: file_path
    quality: '1.0'
    samp_rate: audio_samp_rate
  states: {state: disabled}
- name: satnogs_ogg_source_0
  id: satnogs_ogg_source
  parameters:
    channels: '1'
    filename: ogg_file
    repeat: 'False'
  states: {}
- name: satnogs_tcp_rigctl_msg_source_0
  id: satnogs_tcp_rigctl_msg_source
  parameters:
    addr: '"127.0.0.1"'
    interval: int(1000.0/doppler_correction_per_sec) + 1
    mode: 'False'
    mtu: '1500'
    port: rigctl_port
  states: {state: disabled}
- name: satnogs_udp_msg_sink_0_0
  id: satnogs_udp_msg_sink
  parameters:
    addr: udp_IP
    mtu: '1500'
    port: udp_port
  states: {state: disabled}
- name: satnogs_waterfall_sink_0
  id: satnogs_waterfall_sink
  parameters:
    center_freq: rx_freq
    fft_size: '1024'
    filename: waterfall_file_path
    mode: '1'
    rps: '10'
    samp_rate: baudrate*decimation
  states: {state: disabled}
- name: soapy_rx_device
  id: parameter
  parameters:
    type: str
    value: '"driver=invalid"'
  states: {state: disabled}
- name: soapy_source_0_0
  id: soapy_source
  parameters:
    ant0: antenna
    args: dev_args
    balance0: '0'
    bw0: bw
    center_freq0: rx_freq - lo_offset
    correction0: ppm
    dc_offset0: '0'
    dc_removal0: dc_removal
    dev: soapy_rx_device
    devname: custom
    gain_mode0: gain_mode
    nco_freq0: bb_freq
    overall_gain0: gain
    samp_rate: samp_rate_rx
    sdrplay_biastee: 'True'
    settings0: other_settings
    stream_args: stream_args
    tune_args0: tune_args
    type: fc32
  states: {state: disabled}
- name: stream_args
  id: parameter
  parameters:
    label: Soapy Stream arguments
    type: str
    value: '""'
  states: {state: disabled}
- name: tune_args
  id: parameter
  parameters:
    label: Soapy Channel Tune arguments
    type: str
    value: '""'
  states: {state: disabled}
- name: udp_IP
  id: parameter
  parameters:
    type: str
    value: '"127.0.0.1"'
  states: {state: disabled}
- name: udp_dump_host
  id: parameter
  parameters:
    comment: |-
      None to disable
      '127.0.0.1' to enable on loopback
    type: str
    value: '""'
  states: {state: disabled}
- name: udp_dump_port
  id: parameter
  parameters:
    type: intx
    value: '57356'
  states: {state: disabled}
- name: udp_port
  id: parameter
  parameters:
    type: intx
    value: '16887'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: doppler_corrected
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: doppler_corrected
  states: {state: disabled}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: doppler_corrected
  states: {state: disabled}
- name: waterfall_file_path
  id: parameter
  parameters:
    type: str
    value: '"/tmp/waterfall.dat"'
  states: {state: disabled}

connections:
- [analog_quadrature_demod_cf_0_0, '0', dc_blocker_xx_0, '0']
- [analog_quadrature_demod_cf_0_0_0, '0', pfb_arb_resampler_xxx_1, '0']
- [analog_quadrature_demod_cf_0_0_0_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_vco_c_0, '0']
- [blocks_multiply_xx_0, '0', low_pass_filter_0, '0']
- [blocks_vco_c_0, '0', blocks_multiply_xx_0, '1']
- [dc_blocker_xx_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [dc_blocker_xx_0_0, '0', satnogs_ogg_encoder_0, '0']
- [digital_binary_slicer_fb_0, '0', satnogs_frame_decoder_0_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0_0_0, '0']
- [low_pass_filter_0_0, '0', analog_quadrature_demod_cf_0_0_0_0, '0']
- [pfb_arb_resampler_xxx_1, '0', dc_blocker_xx_0_0, '0']
- [pfb_arb_resampler_xxx_1_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [satnogs_doppler_compensation_0, '0', virtual_sink_0, '0']
- [satnogs_frame_decoder_0_0, out, satnogs_json_converter_0, in]
- [satnogs_json_converter_0, out, satnogs_frame_file_sink_0_1_0, frame]
- [satnogs_json_converter_0, out, satnogs_udp_msg_sink_0_0, in]
- [satnogs_ogg_source_0, '0', pfb_arb_resampler_xxx_1_0, '0']
- [satnogs_tcp_rigctl_msg_source_0, freq, satnogs_doppler_compensation_0, doppler]
- [soapy_source_0_0, '0', satnogs_doppler_compensation_0, '0']
- [virtual_source_0, '0', blocks_delay_0, '0']
- [virtual_source_0, '0', low_pass_filter_0_0, '0']
- [virtual_source_0, '0', satnogs_iq_sink_0, '0']
- [virtual_source_0, '0', satnogs_waterfall_sink_0, '0']
- [virtual_source_0_0, '0', blocks_udp_sink_0_0, '0']

metadata:
  file_format: 1
